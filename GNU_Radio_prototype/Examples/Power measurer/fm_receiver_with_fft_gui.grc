<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fm_receiver_with_fft_gui_grc</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_sdr_hardware_freq</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>heterodyne_freq</value></param>
<param><key>value</key><value>-0.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4.8e6</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>IF_mixer</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>blocks_probe_signal_vx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter</value></param>
<param><key>cutoff_freq</key><value>70000</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>20000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>multiply_output_volume</value></param>
<param><key>const</key><value>0.6</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>output_audio_final</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>probe_vector_if</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_sdr_hardware_freq - heterodyne_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>src_hackrf</value></param>
<param><key>bb_gain0</key><value>30</value></param>
<param><key>freq0</key><value>100*1e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>src_heterodyne</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>heterodyne_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>stream_to_vector_if</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>vector_sink_if</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>wbfm_receive</value></param>
<param><key>audio_decimation</key><value>10</value></param>
<param><key>quad_rate</key><value>480e3</value></param>
</block>
<connection><source_block_id>IF_mixer</source_block_id><sink_block_id>low_pass_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>IF_mixer</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>IF_mixer</source_block_id><sink_block_id>stream_to_vector_if</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>IF_mixer</source_block_id><sink_block_id>vector_sink_if</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter</source_block_id><sink_block_id>wbfm_receive</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multiply_output_volume</source_block_id><sink_block_id>output_audio_final</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>src_hackrf</source_block_id><sink_block_id>IF_mixer</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>src_heterodyne</source_block_id><sink_block_id>IF_mixer</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>stream_to_vector_if</source_block_id><sink_block_id>probe_vector_if</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wbfm_receive</source_block_id><sink_block_id>multiply_output_volume</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
