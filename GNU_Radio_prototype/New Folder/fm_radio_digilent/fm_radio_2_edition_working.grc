<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_sdr_hardware_freq</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>curr_if_freq_label</value></param>
<param><key>value</key><value>hackrf_freq_slider - heterodyne_freq_slider</value></param>
<param><key>label</key><value>Current Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>hackrf_freq_slider</value></param>
<param><key>value</key><value>center_sdr_hardware_freq</value></param>
<param><key>label</key><value>SDR frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>center_sdr_hardware_freq - 1e6</value></param>
<param><key>step</key><value>50e3</value></param>
<param><key>stop</key><value>center_sdr_hardware_freq + 1e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>heterodyne_freq_slider</value></param>
<param><key>value</key><value>-1.10e6</value></param>
<param><key>label</key><value>IF frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-5e6</value></param>
<param><key>step</key><value>50e3</value></param>
<param><key>stop</key><value>5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>low_pass_filter_cutoff_freq</value></param>
<param><key>value</key><value>70e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>low_pass_filter_cutoff_freq_slider</value></param>
<param><key>value</key><value>low_pass_filter_cutoff_freq</value></param>
<param><key>label</key><value>Filter cutoff freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>low_pass_filter_cutoff_freq - 40e3</value></param>
<param><key>step</key><value>5e3</value></param>
<param><key>stop</key><value>low_pass_filter_cutoff_freq + 40e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>low_pass_trans_width_slider</value></param>
<param><key>value</key><value>20e3</value></param>
<param><key>label</key><value>Filter trans width fr</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>5e3</value></param>
<param><key>step</key><value>5e3</value></param>
<param><key>stop</key><value>50e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>output_final_volume_slider</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.2</value></param>
<param><key>step</key><value>0.2</value></param>
<param><key>stop</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>IF_mixer</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter</value></param>
<param><key>cutoff_freq</key><value>low_pass_filter_cutoff_freq_slider</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>low_pass_trans_width_slider</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>multiply_output_volume</value></param>
<param><key>const</key><value>output_final_volume_slider</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>output_audio_final</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_after_low_pass</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>48*1e4</value></param>
<param><key>fc</key><value>hackrf_freq_slider - heterodyne_freq_slider</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"FFT after filter"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_after_wbfm</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>48*1e3</value></param>
<param><key>fc</key><value>hackrf_freq_slider - heterodyne_freq_slider</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"FFT audio"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_hackrf</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>2*1e6</value></param>
<param><key>fc</key><value>hackrf_freq_slider</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"FFT before filter"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_sdr_hardware_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>src_heterodyne</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>heterodyne_freq_slider</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>wbfm_receive</value></param>
<param><key>audio_decimation</key><value>10</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>quad_rate</key><value>480e3</value></param>
</block>
<connection><source_block_id>IF_mixer</source_block_id><sink_block_id>low_pass_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter</source_block_id><sink_block_id>qtgui_freq_sink_after_low_pass</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter</source_block_id><sink_block_id>wbfm_receive</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multiply_output_volume</source_block_id><sink_block_id>output_audio_final</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>IF_mixer</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_hackrf</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>src_heterodyne</source_block_id><sink_block_id>IF_mixer</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wbfm_receive</source_block_id><sink_block_id>multiply_output_volume</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wbfm_receive</source_block_id><sink_block_id>qtgui_freq_sink_after_wbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
